## config/boards/shields/numpad/Kconfig.defconfig
```kconfig
CONFIG_ZMK_BLE_EXPERIMENTAL_FEATURES=y
config SHIELD_NUMPAD
    def_bool $(shields_list_contains, numpad)
```
